# Keil uVision project STM32F767_W25QXX.uvprojx, settings and files
target STM32F767_W25QXX (6220000::V6.22::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F767_W25QXX
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\HARDWARE\QSPI;.\CherrySF;.\CherrySF\norflash;.\HARDWARE\sys
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Hardwere
    ./HARDWARE/QSPI/: qspi.c
    ./HARDWARE/sys/: sys.c
  group CherrySF
    ./CherrySF/port/stm32/: chry_sflash_port_stm32.c
    ./CherrySF/norflash/: chry_sflash_norflash.c
software components: CMSIS:CORE 6.1.0
